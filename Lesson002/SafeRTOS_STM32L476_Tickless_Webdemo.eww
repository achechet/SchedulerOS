<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SafeRTOS_STM32L476_Tickless_Webdemo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


