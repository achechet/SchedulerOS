# IAR project SafeRTOS_STM32L476_Tickless_Webdemo.ewp, settings and files
configuration NUCLEO-L476RG-Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO; USE_IOEXPANDER; INCLUDE_DEMO_DISPLAY=0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: include; common\include; SafeRTOS\kernel\include; SafeRTOS\config; SafeRTOS\queue_registry; STM32L4xx_PeriphLib\STM32L4xx_HAL_Driver\Inc; STM32L4xx_PeriphLib\CMSIS\Device\ST\STM32L4xx\Include; STM32L4xx_PeriphLib\CMSIS\Include; STM32L4xx_PeriphLib\BSP\STM32L476G-Discovery; STM32L4xx_PeriphLib\BSP\STM32L4xx_Nucleo
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: include
  OBJCOPY.OOCOutputFile: SafeRTOS_STM32L476_Tickless_Webdemo.srec
  ILINK.IlinkOutputFile: SafeRTOS_STM32L476_Tickless_Webdemo.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32L476G-Disco-Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L476VG ST STM32L476VG
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L476G_DISCO_REVC; USE_IOEXPANDER; INCLUDE_DEMO_DISPLAY=0
  ICCARM.CCIncludePath2: include; common\include; kernel_source\include; kernel_source\portable\001_IAR\071_STM32L4xx_Tickless; STM32L4xx_PeriphLib\STM32L4xx_HAL_Driver\Inc; STM32L4xx_PeriphLib\CMSIS\Device\ST\STM32L4xx\Include; STM32L4xx_PeriphLib\CMSIS\Include; STM32L4xx_PeriphLib\BSP\STM32L476G-Discovery; STM32L4xx_PeriphLib\BSP\STM32L4xx_Nucleo
  group (top)
    ./: stm32l476xx_flash.icf
  group Common
    Common/: BlockQ.c blocktim.c comtest.c countsem.c death.c dynamic.c flash.c MathsTest.c PollQ.c semtest.c TaskMutex.c TaskNotify.c TimerDemo.c
  group Common/include
    Common/include/: BlockQ.h blocktim.h comtest.h countsem.h countsemTimer.h death.h dynamic.h flash.h MathsTest.h PollQ.h semtest.h serial.h TimerDemo.h
  group Include
    include/: FullDemo.h ParTest.h PortSpecifics.h
  group Kernel
    SafeRTOS/kernel/: IAR_STM32L4xx_Demo_Project.a
  group Kernel/config
    SafeRTOS/config/: SafeRTOSConfig.h
  group Kernel/include
    SafeRTOS/kernel/include/: eventgroups.h list.h mpu.h mpuAPI.h mutex.h portable.h portfeatures.h portmacro.h portmpu.h projdefs.h queue.h runtimestats.h SafeRTOS.h SafeRTOS_API.h semaphore.h task.h timers.h
  group Kernel/queue_registry
    SafeRTOS/queue_registry/: queue_register.h
  group Source
    source/: countsemTimer.c FullDemo.c main.c ParTest.c PortSpecifics.c SafeRTOSConfig.c serial.c
  group STM32L4xx_StdPeriph_Lib/BSP/Components
    STM32L4xx_PeriphLib/BSP/Components/hx8347g/: hx8347g.c hx8347g.h
    STM32L4xx_PeriphLib/BSP/Components/stmpe1600/: stmpe1600.c stmpe1600.h
    STM32L4xx_PeriphLib/BSP/Components/stmpe811/: stmpe811.c stmpe811.h
  group STM32L4xx_StdPeriph_Lib/BSP/STM32L476G-Discovery
    STM32L4xx_PeriphLib/BSP/STM32L476G-Discovery/: stm32l476g_discovery.c stm32l476g_discovery.h
  group STM32L4xx_StdPeriph_Lib/BSP/STM32L4xx_Nucleo
    STM32L4xx_PeriphLib/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c stm32l4xx_nucleo.h
  group STM32L4xx_StdPeriph_Lib/CMSIS
    STM32L4xx_PeriphLib/CMSIS/Device/ST/STM32L4xx/Source/: startup_stm32l476xx.s system_stm32l4xx.c
  group STM32L4xx_StdPeriph_Lib/STM32L4xx_HAL_Driver/inc
    STM32L4xx_PeriphLib/STM32L4xx_HAL_Driver/Inc/: stm32_assert.h stm32l4xx_hal.h stm32l4xx_hal_adc.h stm32l4xx_hal_adc_ex.h stm32l4xx_hal_can.h stm32l4xx_hal_comp.h stm32l4xx_hal_conf.h stm32l4xx_hal_cortex.h stm32l4xx_hal_crc.h stm32l4xx_hal_crc_ex.h stm32l4xx_hal_cryp.h stm32l4xx_hal_cryp_ex.h stm32l4xx_hal_dac.h stm32l4xx_hal_dac_ex.h stm32l4xx_hal_def.h stm32l4xx_hal_dfsdm.h stm32l4xx_hal_dma.h stm32l4xx_hal_firewall.h stm32l4xx_hal_flash.h stm32l4xx_hal_flash_ex.h stm32l4xx_hal_flash_ramfunc.h stm32l4xx_hal_gpio.h stm32l4xx_hal_gpio_ex.h stm32l4xx_hal_hcd.h stm32l4xx_hal_i2c.h stm32l4xx_hal_i2c_ex.h stm32l4xx_hal_irda.h stm32l4xx_hal_irda_ex.h stm32l4xx_hal_iwdg.h stm32l4xx_hal_lcd.h stm32l4xx_hal_lptim.h stm32l4xx_hal_nand.h stm32l4xx_hal_nor.h stm32l4xx_hal_opamp.h stm32l4xx_hal_opamp_ex.h stm32l4xx_hal_pcd.h stm32l4xx_hal_pcd_ex.h stm32l4xx_hal_pwr.h stm32l4xx_hal_pwr_ex.h stm32l4xx_hal_qspi.h stm32l4xx_hal_rcc.h stm32l4xx_hal_rcc_ex.h stm32l4xx_hal_rng.h stm32l4xx_hal_rtc.h stm32l4xx_hal_rtc_ex.h stm32l4xx_hal_sai.h stm32l4xx_hal_sd.h stm32l4xx_hal_smartcard.h stm32l4xx_hal_smartcard_ex.h stm32l4xx_hal_smbus.h stm32l4xx_hal_spi.h stm32l4xx_hal_spi_ex.h stm32l4xx_hal_sram.h stm32l4xx_hal_swpmi.h stm32l4xx_hal_tim.h stm32l4xx_hal_tim_ex.h stm32l4xx_hal_tsc.h stm32l4xx_hal_uart.h stm32l4xx_hal_uart_ex.h stm32l4xx_hal_usart.h stm32l4xx_hal_usart_ex.h stm32l4xx_hal_wwdg.h stm32l4xx_ll_fmc.h stm32l4xx_ll_sdmmc.h stm32l4xx_ll_usb.h
  group STM32L4xx_StdPeriph_Lib/STM32L4xx_HAL_Driver/src
    STM32L4xx_PeriphLib/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_uart.c stm32l4xx_hal_usart.c stm32l4xx_ll_fmc.c
