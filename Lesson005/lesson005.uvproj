# Keil uVision project lesson005.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: SC000 HED
  cpu: CLOCK(28000000) CPUTYPE(SC000) ESEL EBIG
  output: lesson005 +hex
  AfterMake: fromelf --bin --output .\Objects\ASM_GPIO.bin .\Objects\ASM_GPIO.axf
  c flags: Optim=1
  asm include: .\inc
  memory RVCT4: ROM 0x0 size 0x69000
  memory RVCT9: RAM 0x20000000 size 0x2700
  group Source Group 1
    C:/Keil/ARM/Device/HED/CIU98M25/Source/: CIU98M25_Startup.s
    ./: main.c
