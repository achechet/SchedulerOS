# Keil uVision project lesson004.uvproj, settings and files
target CIU98428F_DemoCOS (ARM-ADS)
  device: SC000 HED
  cpu: CLOCK(28000000) CPUTYPE(SC000) ESEL EBIG
  output: Lesson004 +hex
  c flags: Optim=1
  c include: .\INC;.\API
  memory RVCT4: ROM 0x0 size 0x69000
  memory RVCT9: RAM 0x20000000 size 0x2700
  group Demo
    ./SRC/: startup.s main.c DEMO_APDU.c DEMO_SubFunc.c
  group API
    ./API/: CIU98428F_API_Base_NoNVM.c CIU98428F_API_Base_NoNVM.h CIU98428F_API_DES.lib CIU98428F_API_NVM_STABILITY.c CIU98428F_NVM_stability.s
