# Keil uVision project test.uvproj, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: SC000 HED
  cpu: CLOCK(28000000) CPUTYPE(SC000) ESEL EBIG
  output: test
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  group Source Group 1
    C:/Keil_v5/ARM/Device/HED/CIU98428F/Source/: CIU98428F_Startup.s
    ./: main.c
