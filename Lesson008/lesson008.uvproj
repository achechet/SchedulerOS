# Keil uVision project lesson008.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: SC000 HED
  cpu: CLOCK(28000000) CPUTYPE(SC000) ESEL EBIG
  output: lesson008 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x69000
  memory RVCT9: RAM 0x20000000 size 0x2700
  group Source Group 1
    ./: main.c
    C:/Keil/ARM/Device/HED/CIU98428F/Source/: CIU98428F_Startup.s
